Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 2755e27c-a042-45a6-91c8-5dd105aca255, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-14T19:56:41+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12843210_A_G7080SCVi_ED:21708062_A_12843210_G7080SCVi_ED, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_OBSW, z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 598 mm; Height: 805 mm; Depth: 550 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 21708062_A_12843210_G7080SCVi_ED; sets with these values: 2

# IfcDistributionPort, Port_357888_1
Description: Flow; FlowDirection: SOURCEANDSINK
